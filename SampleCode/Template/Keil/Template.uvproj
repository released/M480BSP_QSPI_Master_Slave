# Keil uVision project Template.uvproj, settings and files
target QSPI_Master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_QSPI_MASTER
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c spi.c gpio.c pdma.c timer.c qspi.c
  group User
    ../: main.c
target QSPI_Slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_QSPI_SLAVE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
